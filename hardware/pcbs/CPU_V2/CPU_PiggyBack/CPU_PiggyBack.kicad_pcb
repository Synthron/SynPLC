# Repository Synthron/SynPLC (continued)

## KiCad design pcbs/Platinen/kicad/AO_V2/AO_V2.kicad_pcb

Parts:
C1, C2, C5, C6, C7, C8, C9, C10, C11, C12, C13, C16, C18, C19, C21, C22, C23, C24, C33, C34, C35, C36, C37, C38: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4: 20p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C14, C15, C17, C20: 1µ; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C25, C26, C27, C28, C29, C30, C31, C32: 270p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4: LED; LED_D3.0mm
D5: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
D6: SM6T36A; D_SMB
D7, D8, D9, D10: LL4148; D_MiniMELF
D11, D12, D13, D14: BAV199; SOT-23
F1: PFRA 010; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
FB1: Ferrite_Bead; SMB-002
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
J2: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J3, J4: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Horizontal
J5, J6, J7, J8, J9: TBL009-500-02GY-2GY; TBL00950002GY2GY; Manufacturer_Part_Number TBL009-500-02GY-2GY; Mouser Part Number 490-TBL00950002GY2GY
J10, J11: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
K1, K2, K3, K4: G6K-2; Relay_DPDT_Omron_G6K-2G
Q1, Q2, Q3, Q4: BC846; SOT-23
R1, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R20, R22, R24, R26, R27, R28, R29: 1k; R_0805_2012Metric
R2: 1M; R_0805_2012Metric
R3, R4, R19, R21, R23, R25, R30, R31, R32, R33, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65: 10k; R_0805_2012Metric
R6: 150; R_0805_2012Metric
R8: 120; R_0805_2012Metric
R34, R35, R36, R37: 62k; R_0805_2012Metric
R38, R39, R40, R41: 43k; R_0805_2012Metric
R42, R43, R44, R45, R46, R47, R48, R49: 100k; R_0805_2012Metric
R66, R68, R70, R72: 100; R_0805_2012Metric
R67, R69, R71, R73: 47; R_0805_2012Metric
SW1: SW_DIP_x05; DIP-10_W7.62mm_Socket
U1: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
U2: MAX485E; SOP-8_3.9x4.9mm_P1.27mm
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U4: AP1117-33; SOT-223-3_TabPin2
U5: ADuM1250AR; SOIC-8_3.9x4.9mm_P1.27mm
U6: L78L05_SOT89; SOT-89-3
U7: MCP4728; MSOP-10_3x3mm_P0.5mm
U8, U9, U10, U11: LM358; SO-8_3.9x4.9mm_P1.27mm
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3V3: C1.1, C2.1, C5.1, C7.1, C8.1, C9.1, C10.1, C11.1, C13.1, C15.1, C16.1, J1.1, R1.2, R9.2, R10.2, R11.2, R12.2, R17.2, R26.2, R27.2, U1.3 (VCC), U2.8 (VCC), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U4.2 (VO), U5.1 (VDD1)
+5V: C19.1, C20.1, C33.1, C34.1, R28.1, R29.1, U5.8 (VDD2), U6.1 (OUT), U7.1 (VDD)
+24V: C17.1, C18.1, C35.1, C36.1, C37.1, C38.1, D11.2, D12.2, D13.2, D14.2, FB1.2, U6.3 (IN), U8.8 (V+), U9.8 (V+), U10.8 (V+), U11.8 (V+)
BUS+: J2.4, J3.9, J4.9
BUS-: J2.3, J3.10, J4.10
CAN_RD: U1.4 (R), U3.45 (PB8)
CAN_TD: U1.1 (D), U3.46 (PB9)
CC1: D7.2 (A), K1.8, Q1.3 (C)
CC1_Lo: R18.2, R19.2, U3.15 (PA5)
CC2: D8.2 (A), K2.8, Q2.3 (C)
CC2_Lo: R20.2, R21.2, U3.16 (PA6)
CC3: D9.2 (A), K3.8, Q3.3 (C)
CC3_Lo: R22.2, R23.2, U3.17 (PA7)
CC4: D10.2 (A), K4.8, Q4.3 (C)
CC4_Lo: R24.2, R25.2, U3.29 (PA8)
DIR: U2.2 (~RE), U2.3 (DE), U3.25 (PB12)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.4, J3.5, J3.6, J3.7, J3.8, J4.5, J4.6, J4.7, J4.8, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), R3.2, R4.2, R19.1, R21.1, R23.1, R25.1, SW1.6, SW1.7, SW1.8, SW1.9, SW1.10, U1.2 (GND), U2.5 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.1 (GND), U5.4 (GND1)
GND2: C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, D6.2 (A2), D11.1, D12.1, D13.1, D14.1, J5.3, J5.4, J6.3, J6.4, J7.3, J7.4, J8.3, J8.4, J9.3, J9.4, R38.2, R39.2, R40.2, R41.2, R46.2, R47.2, R48.2, R49.2, U5.5 (GND2), U6.2 (GND), U7.4 (~LDAC), U7.10 (VSS), U8.4 (V-), U9.4 (V-), U10.4 (V-), U11.4 (V-)
unnamed: C3.2, R2.2, U3.5 (PD0), Y1.1
unnamed: C4.1, R2.1, U3.6 (PD1), Y1.2
unnamed: C6.1, R1.1, U3.7 (NRST)
unnamed: C21.1, R30.1, U8.3 (+)
unnamed: C22.1, R31.1, U9.3 (+)
unnamed: C23.1, R32.1, U10.3 (+)
unnamed: C24.1, R33.1, U11.3 (+)
unnamed: C25.1, R34.2, R38.1, U8.2 (-)
unnamed: C25.2, R58.1, R66.2, U8.1
unnamed: C26.1, R35.2, R39.1, U9.2 (-)
unnamed: C26.2, R60.1, R68.2, U9.1
unnamed: C27.1, R36.2, R40.1, U10.2 (-)
unnamed: C27.2, R62.1, R70.2, U10.1
unnamed: C28.1, R37.2, R41.1, U11.2 (-)
unnamed: C28.2, R64.1, R72.2, U11.1
unnamed: C29.1, K1.5, R42.2, U8.7
unnamed: C29.2, R42.1, R51.2, U8.6 (-)
unnamed: C30.1, K2.5, R43.2, U9.7
unnamed: C30.2, R43.1, R53.2, U9.6 (-)
unnamed: C31.1, K3.5, R44.2, U10.7
unnamed: C31.2, R44.1, R55.2, U10.6 (-)
unnamed: C32.1, K4.5, R45.2, U11.7
unnamed: C32.2, R45.1, R57.2, U11.6 (-)
unnamed: D1.2 (A), R13.1
unnamed: D2.2 (A), R14.1
unnamed: D3.2 (A), R15.1
unnamed: D4.2 (A), R16.1
unnamed: D5.1 (K), FB1.1
unnamed: D5.2 (A), F1.2
unnamed: D6.1 (A1), F1.1, J5.1, J5.2
unnamed: J2.2, R8.1, U1.7 (CANH)
unnamed: J2.6, R6.1, U2.7 (B)
unnamed: J10.1, R6.2
unnamed: J2.5, J10.2, U2.6 (A)
unnamed: J11.1, R8.2
unnamed: J2.1, J11.2, U1.6 (CANL)
unnamed: K1.6, R34.1
unnamed: K2.6, R35.1
unnamed: K3.6, R36.1
unnamed: K4.6, R37.1
unnamed: Q1.1 (B), R18.1
unnamed: Q2.1 (B), R20.1
unnamed: Q3.1 (B), R22.1
unnamed: Q4.1 (B), R24.1
unnamed: R3.1, U3.44 (BOOT0)
unnamed: R4.1, U3.20 (PB2)
unnamed: R9.1, SW1.1, U3.10 (PA0)
unnamed: R10.1, SW1.2, U3.11 (PA1)
unnamed: R11.1, SW1.3, U3.12 (PA2)
unnamed: R12.1, SW1.4, U3.13 (PA3)
unnamed: R13.2, U3.30 (PA9)
unnamed: R14.2, U3.31 (PA10)
unnamed: R15.2, U3.32 (PA11)
unnamed: R16.2, U3.33 (PA12)
unnamed: R17.1, SW1.5, U3.14 (PA4)
unnamed: R28.2, U5.6 (VOB), U7.3 (SDA)
unnamed: R29.2, U5.7 (VOA), U7.2 (SCL)
unnamed: R30.2, U7.6 (VOUTA)
unnamed: R31.2, U7.7 (VOUTB)
unnamed: R32.2, U7.8 (VOUTC)
unnamed: R33.2, U7.9 (VOUTD)
unnamed: R46.1, R50.2, U8.5 (+)
unnamed: R47.1, R52.2, U9.5 (+)
unnamed: R48.1, R54.2, U10.5 (+)
unnamed: R49.1, R56.2, U11.5 (+)
unnamed: R50.1, R58.2
unnamed: R51.1, R59.2
unnamed: R52.1, R60.2
unnamed: R53.1, R61.2
unnamed: R54.1, R62.2
unnamed: R55.1, R63.2
unnamed: R56.1, R64.2
unnamed: R57.1, R65.2
unnamed: R59.1, R66.1, R67.2
unnamed: R61.1, R68.1, R69.2
unnamed: R63.1, R70.1, R71.2
unnamed: R65.1, R72.1, R73.2
OUT1: D11.3, J6.1, J6.2, K1.7, R67.1
OUT2: D12.3, J7.1, J7.2, K2.7, R69.1
OUT3: D13.3, J8.1, J8.2, K3.7, R71.1
OUT4: D14.3, J9.1, J9.2, K4.7, R73.1
RXD: U2.1 (RO), U3.22 (PB11)
SCL: R27.1, U3.42 (PB6), U5.2 (VIA)
SDA: R26.1, U3.43 (PB7), U5.3 (VIB)
SWCLK: J1.3, U3.37 (PA14)
SWIO: J1.2, U3.34 (PA13)
TXD: U2.4 (DI), U3.21 (PB10)
VCC: C12.1, C14.1, D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), J3.1, J3.2, J3.3, J3.4, J4.1, J4.2, J4.3, J4.4, K1.1, K2.1, K3.1, K4.1, U4.3 (VI)

Notes on the sheet:
Address Select
Galvanische Trennung 750VAC Luft- und Kriechstrecke min. 1,5mm
Kanal 1 aktiv Kanal 2 aktiv Kanal 3 aktiv Kanal 4 aktiv

Board: 4 copper layers, 100.0 x 77.0 mm, 157 parts (0 on the bottom side), 106 nets.

## KiCad design pcbs/Platinen/kicad/DO8_V1.2/DO8_V1.2.kicad_pcb

Parts:
C1, C3, C4, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C5: 1µ; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D7, D10, D12, D15: LED; LED_D3.0mm
D5, D6, D8, D9, D11, D13, D14, D16, D18: SM6T36A; D_SMB
D17: 8v2; D_MiniMELF
D19, D20, D21, D22, D23, D24, D25, D26: LL4148; D_MiniMELF
IC1: ITS4880R; PG-DSO-36; MPN ITS4880R
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J2, J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J5, J6: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Horizontal
J7, J8, J9, J10, J11: TBL009-500-02GY-2GY; TBL00950002GY2GY; Manufacturer_Part_Number TBL009-500-02GY-2GY; Mouser Part Number 490-TBL00950002GY2GY
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: BC846; SOT-23
Q9: FQP27P06; TO-220-3_Vertical
R1, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R32, R35, R37, R39, R41, R43, R45, R47, R50, R51: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 150; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17, R18, R19, R20, R21, R22, R23, R24: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R25, R26, R27, R28, R29, R30, R31, R33: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R34, R36, R38, R40, R42, R44, R46, R48, R49: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_DIP_x05; SW_DIP_SPSTx05_Slide_9.78x14.88mm_W7.62mm_P2.54mm
U1: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
U2: MAX485E; SO-8_3.9x4.9mm_P1.27mm
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U4: AP1117-33; SOT-223-3_TabPin2
U5, U6, U7, U8: TLP291-4; SOIC-16_4.55x10.3mm_P1.27mm
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3V3: C1.1, C4.1, C5.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, J1.1, R4.2, R5.2, R6.2, R7.2, R8.2, R50.1, U1.3 (VCC), U2.8 (VCC), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U4.2 (VO), U7.10, U7.12, U7.14, U7.16, U8.10, U8.12, U8.14, U8.16
+24V: C15.1, D17.1 (K), IC1.3 (LS), IC1.TH@1 (VBB), IC1.TH@2 (VBB@1), Q9.3 (S), U5.10, U5.12, U5.14, U5.16, U6.10, U6.12, U6.14, U6.16
BUS+: J4.4, J5.9, J6.9
BUS-: J4.3, J5.10, J6.10
CAN_RD: U1.4 (R), U3.45 (PB8)
CAN_TD: U1.1 (D), U3.46 (PB9)
CH1: R9.2, U3.15 (PA5)
CH2: R10.2, U3.16 (PA6)
CH3: R11.2, U3.17 (PA7)
CH4: R12.2, U3.29 (PA8)
CH5: R13.2, U3.30 (PA9)
CH6: R14.2, U3.31 (PA10)
CH7: R15.2, U3.32 (PA11)
CH8: R16.2, U3.33 (PA12)
DIR: U2.2 (~RE), U2.3 (DE), U3.25 (PB12)
FB1: R32.1, U3.18 (PB0), U7.9
FB2: R35.1, U3.19 (PB1), U7.11
FB3: R37.1, U3.20 (PB2), U7.13
FB4: R39.1, U3.39 (PB3), U7.15
FB5: R41.1, U3.40 (PB4), U8.9
FB6: R43.1, U3.41 (PB5), U8.11
FB7: R45.1, U3.42 (PB6), U8.13
FB8: R47.1, U3.43 (PB7), U8.15
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D7.1 (K), D10.1 (K), D12.1 (K), D15.1 (K), J1.4, J5.5, J5.6, J5.7, J5.8, J6.5, J6.6, J6.7, J6.8, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), Q7.2 (E), Q8.2 (E), R1.1, SW1.6, SW1.7, SW1.8, SW1.9, SW1.10, U1.2 (GND), U2.5 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.1 (GND)
GND2: C15.2, D5.2 (A2), D6.2 (A2), D8.2 (A2), D9.2 (A2), D11.2 (A2), D13.2 (A2), D14.2 (A2), D16.2 (A2), D18.2 (A2), IC1.19 (GND), J11.3, J11.4, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R33.1, R49.2, U7.2, U7.4, U7.6, U7.8, U8.2, U8.4, U8.6, U8.8
unnamed: C6.1, R51.1, U3.5 (PD0), Y1.1
unnamed: C7.2, R51.2, U3.6 (PD1), Y1.2
unnamed: C8.1, R50.2, U3.7 (NRST)
unnamed: D1.2 (A), R32.2
unnamed: D2.2 (A), R35.2
unnamed: D3.2 (A), R37.2
unnamed: D4.2 (A), R39.2
unnamed: D7.2 (A), R41.2
unnamed: D10.2 (A), R43.2
unnamed: D11.1 (A1), D23.2 (A), IC1.27 (OUT5@2), IC1.28 (OUT5), J9.1, J9.2
unnamed: D12.2 (A), R45.2
unnamed: D13.1 (A1), D24.2 (A), IC1.25 (OUT6@2), IC1.26 (OUT6), J9.3, J9.4
unnamed: D14.1 (A1), D25.2 (A), IC1.23 (OUT7@2), IC1.24 (OUT7), J10.1, J10.2
unnamed: D15.2 (A), R47.2
unnamed: D16.1 (A1), D26.2 (A), IC1.21 (OUT8@2), IC1.22 (OUT8), J10.3, J10.4
unnamed: D17.2 (A), Q9.1 (G), R49.1
unnamed: D18.1 (A1), J11.1, J11.2, Q9.2 (D)
unnamed: D19.1 (K), R34.1
unnamed: D5.1 (A1), D19.2 (A), IC1.35 (OUT1@2), IC1.36 (OUT1), J7.1, J7.2
unnamed: D20.1 (K), R36.1
unnamed: D6.1 (A1), D20.2 (A), IC1.33 (OUT2@2), IC1.34 (OUT2), J7.3, J7.4
unnamed: D21.1 (K), R38.1
unnamed: D8.1 (A1), D21.2 (A), IC1.31 (OUT3@2), IC1.32 (OUT3), J8.1, J8.2
unnamed: D22.1 (K), R40.1
unnamed: D9.1 (A1), D22.2 (A), IC1.29 (OUT4@2), IC1.30 (OUT4), J8.3, J8.4
unnamed: D23.1 (K), R42.1
unnamed: D24.1 (K), R44.1
unnamed: D25.1 (K), R46.1
unnamed: D26.1 (K), R48.1
unnamed: IC1.6 (IN1), R25.2, U5.15
unnamed: IC1.7 (IN2), R26.2, U5.13
unnamed: IC1.8 (IN3), R27.2, U5.11
unnamed: IC1.9 (IN4), R28.2, U5.9
unnamed: IC1.10 (IN5), R29.2, U6.15
unnamed: IC1.11 (IN6), R30.2, U6.13
unnamed: IC1.12 (IN7), R31.2, U6.11
unnamed: IC1.13 (IN8), R33.2, U6.9
unnamed: J2.1, R2.1
unnamed: J2.2, J4.1, U1.6 (CANL)
unnamed: J3.1, R3.1
unnamed: J3.2, J4.5, U2.6 (A)
unnamed: J4.2, R2.2, U1.7 (CANH)
unnamed: J4.6, R3.2, U2.7 (B)
unnamed: Q1.1 (B), R9.1
unnamed: Q1.3 (C), U5.2
unnamed: Q2.1 (B), R10.1
unnamed: Q2.3 (C), U5.4
unnamed: Q3.1 (B), R11.1
unnamed: Q3.3 (C), U5.6
unnamed: Q4.1 (B), R12.1
unnamed: Q4.3 (C), U5.8
unnamed: Q5.1 (B), R13.1
unnamed: Q5.3 (C), U6.2
unnamed: Q6.1 (B), R14.1
unnamed: Q6.3 (C), U6.4
unnamed: Q7.1 (B), R15.1
unnamed: Q7.3 (C), U6.6
unnamed: Q8.1 (B), R16.1
unnamed: Q8.3 (C), U6.8
unnamed: R1.2, U3.44 (BOOT0)
unnamed: R4.1, SW1.1, U3.10 (PA0)
unnamed: R5.1, SW1.2, U3.11 (PA1)
unnamed: R6.1, SW1.3, U3.12 (PA2)
unnamed: R7.1, SW1.4, U3.13 (PA3)
unnamed: R8.1, SW1.5, U3.14 (PA4)
unnamed: R17.1, U5.1
unnamed: R18.1, U5.3
unnamed: R19.1, U5.5
unnamed: R20.1, U5.7
unnamed: R21.1, U6.1
unnamed: R22.1, U6.3
unnamed: R23.1, U6.5
unnamed: R24.1, U6.7
unnamed: R34.2, U7.7
unnamed: R36.2, U7.5
unnamed: R38.2, U7.3
unnamed: R40.2, U7.1
unnamed: R42.2, U8.7
unnamed: R44.2, U8.5
unnamed: R46.2, U8.3
unnamed: R48.2, U8.1
RXD: U2.1 (RO), U3.22 (PB11)
SWCLK: J1.3, U3.37 (PA14)
SWIO: J1.2, U3.34 (PA13)
TXD: U2.4 (DI), U3.21 (PB10)
VCC: C2.1, C3.1, J5.1, J5.2, J5.3, J5.4, J6.1, J6.2, J6.3, J6.4, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, U4.3 (VI)

Notes on the sheet:
Galvanische Trennung mindestens 1,5mm

Board: 4 copper layers, 100.0 x 77.0 mm, 123 parts (0 on the bottom side), 111 nets.
