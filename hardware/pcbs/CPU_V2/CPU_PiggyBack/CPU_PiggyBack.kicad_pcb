# Repository Synthron/SynPLC

File README.md:

# SynPLC

Open Source modular PLC with Microcontrollers

**WORK IN PROGRESS**

# To-Dos

## Repo

- [x] Rewrite documentation in english
- [x] add reviewed PCBs
- [ ] fill out tech specs of modules once programmed
- [ ] Cleanup Repo
  - [ ] better folder structure
  - [X] delete obsolete files

## Hardware

- [x] Order new PCBs with STM32s
- [x] Assemble new PCBs
- [ ] Test new hardware
  - [X] DO
  - [X] DI
  - [ ] AO
  - [ ] AI
  - [ ] XT
- [ ] New Modules
  - [ ] CPU V2
    - [X] Layout
    - [X] Review
    - [ ] Ordered
  - [ ] Relais Module
  - [ ] PWM Module

## Software

- [ ] Write Software for new PCBs
  - [ ] CPU
  - [ ] DO
  - [ ] DI
  - [ ] AO
  - [ ] AI
  - [ ] XT
- [ ] Porting of SR485 protocol to new hardware
  - [ ] Make it use Interrupts
  - [ ] Make it more efficient (processing)
  - [ ] implement failsafes when no answer
- [ ] Define and program CAN protocol
- [ ] Write generalized Code for CPU
- [ ] ~~define structured Text~~ (postponed)
- [ ] ~~import structured text and parse into running code~~ (postponed)

## Possible Fixes

- [x] ~~MAX485 with 5V supply voltage on all IO modules ?~~
  - changed to 3V3 on the CPU
- [x] DIs and DO (alt. switches) re-soldering (dead channels)
- [x] better connector for CPU
- [ ] parametrize RS485 lib a bit more (tbd)

## issues

- [x] weird additional bytes sent by slave after ACK and CS???
  - resolved

## KiCad design hardware/pcbs/CPU_V2/CPU_PiggyBack/CPU_PiggyBack.kicad_pcb

Parts:
C1: 100µF; CP_Elec_5x5.8
C2, C4, C6, C8: 1n; C_0805_2012Metric
C3, C5, C7, C9: 470n; C_0805_2012Metric
C10, C11, C12: 100n; C_0805_2012Metric
C13: 10µ; CP_Elec_5x5.8
D1, D2, D3, D4, D5, D8, D12, D16, D20: P6SMB36CA; D_SMA
D6, D10, D14, D18, D30, D31, D32, D33: 6v8; D_MiniMELF
D7, D11, D15, D19: LL4148; D_MiniMELF
D9, D13, D17, D21: 5v6; D_MiniMELF
D22, D23, D24, D25, D26, D27, D28, D29: LED; LED_D3.0mm
F1, F2, F3, F4: 1812L035/60MR; R_1812_4532Metric
FB1, FB2: SMB-002
FB3, FB4, FB5, FB6, FB7, FB8, FB9, FB10: SMB-001
J1: I2C; PinSocket_1x04_P2.54mm_Vertical
J2, J3, J4, J5, J6: TBL009-500-02GY-2GY; TBL00950002GY2GY
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: BCX53; SOT-89-3
Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16: BC856; SOT-23
R1, R2, R3, R4, R21, R22, R23, R24, R27, R31, R35, R39, R41, R42, R43, R44, R49, R50, R51, R52, R57, R58, R59, R60: 10k; R_0805_2012Metric
R5, R9, R14, R18, R25, R29, R33, R37: 2k2; R_0805_2012Metric
R6, R10, R13, R17: 12k; R_0805_2012Metric
R7, R8, R11, R12, R15, R16, R19, R20: 100k; R_0805_2012Metric
R26, R30, R34, R38, R45, R46, R47, R48, R53, R54, R55, R56: 1k; R_0805_2012Metric
R28, R32, R36, R40: 47k; R_0805_2012Metric
U1, U2: PCF8574; SOIC-16W_7.5x10.3mm_P1.27mm
U3, U4, U5: TLP291-4; SOIC-16_4.55x10.3mm_P1.27mm

Connections:
+5V: C10.1, C11.1, C12.1, C13.1, J1.2, Q9.2 (E), Q10.2 (E), Q11.2 (E), Q12.2 (E), Q13.2 (E), Q14.2 (E), Q15.2 (E), Q16.2 (E), R1.2, R2.2, R3.2, R4.2, R5.2, R9.2, R14.2, R18.2, R21.2, R22.2, R23.2, R24.2, U1.16 (VDD), U2.1 (A0), U2.16 (VDD)
+24V: C1.1, FB1.2, Q1.3 (E), Q2.3 (E), Q3.3 (E), Q4.3 (E), R7.2, R11.2, R15.2, R19.2
FB_0: R4.1, U1.9 (P4), U4.10
FB_1: R3.1, U1.10 (P5), U4.12
FB_2: R2.1, U1.11 (P6), U4.14
FB_3: R1.1, U1.12 (P7), U4.16
GND: C10.2, C11.2, C12.2, C13.2, D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), J1.1, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.8 (VSS), U2.2 (A1), U2.3 (A2), U2.8 (VSS), U4.9, U4.11, U4.13, U4.15, U5.9, U5.11, U5.13, U5.15
GND2: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, D2.1 (A1), D3.1 (A1), D4.1 (A1), D5.1 (A1), D8.1 (A1), D12.1 (A1), D16.1 (A1), D20.1 (A1), FB2.2, R8.1, R12.1, R16.1, R20.1, R27.1, R31.1, R35.1, R39.1, U3.9, U3.11, U3.13, U3.15, U4.2, U4.4, U4.6, U4.8, U5.2, U5.4, U5.6, U5.8
IN_0: R24.1, R49.1, U2.4 (P0), U5.10
IN_1: R23.1, R50.1, U2.5 (P1), U5.12
IN_2: R22.1, R51.1, U2.6 (P2), U5.14
IN_3: R21.1, R52.1, U2.7 (P3), U5.16
unnamed: C2.2, Q5.2 (C), R27.2, R28.2, U5.7
unnamed: C3.2, D7.2 (A), R26.2
unnamed: C4.2, Q6.2 (C), R31.2, R32.2, U5.5
unnamed: C5.2, D11.2 (A), R30.2
unnamed: C6.2, Q7.2 (C), R35.2, R36.2, U5.3
unnamed: C7.2, D15.2 (A), R34.2
unnamed: C8.2, Q8.2 (C), R39.2, R40.2, U5.1
unnamed: C9.2, D19.2 (A), R38.2
unnamed: D1.1 (A1), FB2.1, J2.2
unnamed: D1.2 (A2), FB1.1, J2.1
unnamed: D2.2 (A2), FB3.1, J3.1
unnamed: D3.2 (A2), FB4.1, J3.2
unnamed: D4.2 (A2), FB5.1, J4.1
unnamed: D5.2 (A2), FB6.1, J4.2
unnamed: D6.1 (K), D7.1 (K)
unnamed: D6.2 (A), D9.1 (K), R25.1
unnamed: D8.2 (A2), FB7.1, J5.1
unnamed: D9.2 (A), Q5.1 (B), R28.1
unnamed: D10.1 (K), D11.1 (K)
unnamed: D10.2 (A), D13.1 (K), R29.1
unnamed: D12.2 (A2), FB8.1, J5.2
unnamed: D13.2 (A), Q6.1 (B), R32.1
unnamed: D14.1 (K), D15.1 (K)
unnamed: D14.2 (A), D17.1 (K), R33.1
unnamed: D16.2 (A2), FB9.1, J6.1
unnamed: D17.2 (A), Q7.1 (B), R36.1
unnamed: D18.1 (K), D19.1 (K)
unnamed: D18.2 (A), D21.1 (K), R37.1
unnamed: D20.2 (A2), FB10.1, J6.2
unnamed: D21.2 (A), Q8.1 (B), R40.1
unnamed: D22.2 (A), R45.2
unnamed: D23.2 (A), R46.2
unnamed: D24.2 (A), R47.2
unnamed: D25.2 (A), R48.2
unnamed: D26.2 (A), R53.2
unnamed: D27.2 (A), R54.2
unnamed: D28.2 (A), R55.2
unnamed: D29.2 (A), R56.2
unnamed: D30.1 (K), F1.1, FB3.2, R8.2
unnamed: D30.2 (A), R6.1
unnamed: D31.1 (K), F2.1, FB4.2, R12.2
unnamed: D31.2 (A), R10.1
unnamed: D32.1 (K), F3.1, FB5.2, R16.2
unnamed: D32.2 (A), R13.1
unnamed: D33.1 (K), F4.1, FB6.2, R20.2
unnamed: D33.2 (A), R17.1
unnamed: F1.2, Q1.2 (C)
unnamed: F2.2, Q2.2 (C)
unnamed: F3.2, Q3.2 (C)
unnamed: F4.2, Q4.2 (C)
unnamed: FB7.2, R26.1
unnamed: FB8.2, R30.1
unnamed: FB9.2, R34.1
unnamed: FB10.2, R38.1
unnamed: Q1.1 (B), R7.1, R58.2
unnamed: Q2.1 (B), R11.1, R57.2
unnamed: Q3.1 (B), R15.1, R59.2
unnamed: Q4.1 (B), R19.1, R60.2
unnamed: Q5.3 (E), R25.2
unnamed: Q6.3 (E), R29.2
unnamed: Q7.3 (E), R33.2
unnamed: Q8.3 (E), R37.2
unnamed: Q9.1 (B), R41.2
unnamed: Q9.3 (C), R45.1
unnamed: Q10.1 (B), R42.2
unnamed: Q10.3 (C), R46.1
unnamed: Q11.1 (B), R43.2
unnamed: Q11.3 (C), R47.1
unnamed: Q12.1 (B), R44.2
unnamed: Q12.3 (C), R48.1
unnamed: Q13.1 (B), R49.2
unnamed: Q13.3 (C), R53.1
unnamed: Q14.1 (B), R50.2
unnamed: Q14.3 (C), R54.1
unnamed: Q15.1 (B), R51.2
unnamed: Q15.3 (C), R55.1
unnamed: Q16.1 (B), R52.2
unnamed: Q16.3 (C), R56.1
unnamed: R5.1, U3.1
unnamed: R6.2, U4.7
unnamed: R9.1, U3.3
unnamed: R10.2, U4.5
unnamed: R13.2, U4.3
unnamed: R14.1, U3.5
unnamed: R17.2, U4.1
unnamed: R18.1, U3.7
unnamed: R57.1, U3.14
unnamed: R58.1, U3.16
unnamed: R59.1, U3.12
unnamed: R60.1, U3.10
OUT_0: R41.1, U1.4 (P0), U3.2
OUT_1: R42.1, U1.5 (P1), U3.4
OUT_2: R43.1, U1.6 (P2), U3.6
OUT_3: R44.1, U1.7 (P3), U3.8
SCL: J1.4, U1.14 (SCL), U2.14 (SCL)
SDA: J1.3, U1.15 (SDA), U2.15 (SDA)

Notes on the sheet:
IO Interface
Decoupling
Digital Outputs
Addresses: Read = 0x42 Write = 0x43
Grove-Compatible
24V
Addresses: Read = 0x40 Write = 0x41
Bus
LED Indicators
Digital Inputs

Board: 4 copper layers, 100.0 x 77.0 mm, 147 parts (1 on the bottom side), 108 nets.

## KiCad design hardware/pcbs/CPU_V2/CPU_V2/CPU_V2.kicad_pcb

Parts:
C1, C4, C5, C9, C15, C16, C17, C18, C19, C24, C25, C27, C29, C31, C33, C34: 100n; C_0805_2012Metric
C2, C10, C30, C32: 10µ; CP_Elec_5x5.8
C3: 0.22F/5V; CP_Elec_10x10.5
C6, C20: 4µ7; C_0805_2012Metric
C7, C8: 20p; C_0805_2012Metric
C11, C12: 47p; C_0805_2012Metric
C13, C14: 10p; C_0805_2012Metric
C21: 100µ; CP_Elec_5x5.8
C22, C28: 1n; C_0805_2012Metric
C23, C26, C35: 1µ; C_0805_2012Metric
D1: LL4148; D_MiniMELF
D2, D3, D4, D5, D6: LED; LED_D3.0mm
D7, D10: CDSOT23-T24-Q; SOT-23
D8: SM4001; D_MELF
D9: P6SMB36; D_SMA
F1: 60R065XU; Fuse_Littelfuse_395Series
FB1: SMB-001
FB2, FB3: SMB-002
J1: GSD09002SEU
J2: SWD; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: USB_B; USB_B_Lumberg_2411_02_Horizontal
J4: 24V_In; TBL00950002GY2GY
J5: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Horizontal
J6: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J7: SPI Conn; PinHeader_1x06_P2.54mm_Vertical
J8: I2C; PinHeader_1x04_P2.54mm_Vertical
JP1: V_USB; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: SRF3225TAC-101Y; SRF3225TAC
Q1, Q2, Q3, Q5, Q6, Q7, Q8: BSS138; SOT-23
Q4: BC856; SOT-23
R1, R25: 100; R_0805_2012Metric
R2, R3, R4, R5, R6, R7, R8, R12, R13, R17, R18, R19, R31, R32, R33, R42: 10k; R_0805_2012Metric
R9, R10, R11, R29, R30, R43, R44, R45: 1k; R_0805_2012Metric
R14, R15, R16, R20, R24, R26, R35, R36: 22; R_0805_2012Metric
R21, R22, R23, R28, R37, R38: 100k; R_0805_2012Metric
R27: 1M; R_0805_2012Metric
R34: 1k5; R_0805_2012Metric
R39, R41, R47, R48, R49, R50: 4k7; R_0805_2012Metric
R40, R46: 120; R_0805_2012Metric
TP1, TP2: TestPoint; TestPoint_Pad_1.5x1.5mm
U1: STM32F412RETx; LQFP-64_10x10mm_P0.5mm
U2: THN 10-2411WIR; THN 10WIR
U3: AP1117-33; SOT-223-3_TabPin2
U4: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm
U5: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
U6: ESP-01
Y1: 12MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm
Y2: 32.768kHz; Crystal_SMD_SeikoEpson_MC306-4Pin_8.0x3.2mm

Connections:
+3V3: C1.1, C2.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C25.1, C26.1, C27.1, C29.1, C30.1, C31.1, C32.1, C34.1, D1.2 (A), J1.4 (VDD), J2.1, J7.1, Q4.2 (E), Q7.1 (G), Q8.1 (G), R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R12.1, R13.1, R28.2, R39.1, R42.1, R43.1, R44.1, R45.1, R47.2, R49.2, U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U3.2 (VO), U4.8 (VCC), U5.3 (VCC), U6.7 (VCC)
+5V: C21.1, C23.1, C24.1, C35.1, J5.1, J5.2, J5.3, J5.4, J8.2, JP1.1 (A), R9.1, R10.1, R11.1, R29.1, R30.1, R48.2, R50.2, U2.4 (VOUT+), U3.3 (VI)
/BUS+: D10.1 (A1), J5.9, L1.2
/BUS-: D10.2 (A2), J5.10, L1.3
/CAN+: J6.6, R46.1, U5.7 (CANH)
/CAN-: J6.5, R46.2, U5.6 (CANL)
/D+: D7.1 (A1), J3.3 (D+), R35.1
/D-: D7.2 (A2), J3.2 (D-), R36.1
/ESP_RST: C33.1, R42.2, TP2.1, U6.5 (RST)
/RESET: C5.1, R2.2, U1.7 (NRST)
/RS485+: C22.2, J6.2, R39.2, R40.1, U4.7 (B)
/RS485-: C28.1, J6.1, R40.2, R41.1, U4.6 (A)
/SWCLK: J2.3, U1.49 (PA14)
/SWDIO: J2.2, U1.46 (PA13)
/VBAT: C3.1, C4.1, R1.2, U1.1 (VBAT)
/_BUS+: J6.4, L1.1
/_BUS-: J6.3, L1.4
CAN_RX: U1.61 (PB8), U5.4 (R)
CAN_TX: U1.62 (PB9), U5.1 (D)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, D7.3 (common), D10.3 (common), J1.3 (VSS), J1.6 (VSS), J1.11 (SHELL2), J1.12 (SHELL1), J2.4, J3.4 (GND), J3.5 (Shield), J5.5, J5.6, J5.7, J5.8, J7.6, J8.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q5.2 (S), Q6.2 (S), R21.1, R22.1, R23.1, R25.1, R37.1, R38.1, R41.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.6 (VOUT-), U3.1 (GND), U4.5 (GND), U5.2 (GND), U6.2 (GND), Y1.2, Y1.4, Y2.2, Y2.3
I2C1_SCL: Q7.2 (S), R47.1, U1.58 (PB6)
I2C1_SDA: Q8.2 (S), R49.1, U1.59 (PB7)
LED_BOOT: R33.2, U1.53 (PC12)
LED_ERROR: R17.2, U1.55 (PB3)
LED_FLASH: R19.2, U1.57 (PB5)
LED_HEARTBEAT: R32.2, U1.54 (PD2)
LED_RUN: R18.2, U1.56 (PB4)
unnamed: C6.1, U1.30 (VCAP_1)
unnamed: C7.2, R27.1, U1.5 (PH0), Y1.3
unnamed: C8.2, R27.2, U1.6 (PH1), Y1.1
unnamed: C9.1, C10.1, FB1.2, JP1.2 (B)
unnamed: C13.2, U1.3 (PC14), Y2.1
unnamed: C14.2, U1.4 (PC15), Y2.4
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), Q1.3 (D)
unnamed: D2.2 (A), R9.2
unnamed: D3.1 (K), Q2.3 (D)
unnamed: D3.2 (A), R10.2
unnamed: D4.1 (K), Q3.3 (D)
unnamed: D4.2 (A), R11.2
unnamed: D5.1 (K), Q5.3 (D)
unnamed: D5.2 (A), R29.2
unnamed: D6.1 (K), Q6.3 (D)
unnamed: D6.2 (A), R30.2
unnamed: D8.1 (K), U2.1 (VIN+)
unnamed: D8.2 (A), F1.1
unnamed: D9.1 (A1), FB3.2, U2.2 (VIN-)
unnamed: D9.2 (A2), F1.2, FB2.2
unnamed: FB1.1, J3.1 (VBUS)
unnamed: FB2.1, J4.1
unnamed: FB3.1, J4.2
unnamed: J1.1 (CD/DAT3), R15.2
unnamed: J1.2 (CMD), R16.2
unnamed: J1.5 (CLK), R20.2
unnamed: J1.7 (DAT0), R24.2
unnamed: J1.8 (DAT1), R26.2
unnamed: J1.9 (DAT2), R14.2
unnamed: Q1.1 (G), R17.1, R21.2
unnamed: Q2.1 (G), R18.1, R22.2
unnamed: Q3.1 (G), R19.1, R23.2
unnamed: Q4.1 (B), R28.1, R31.2
unnamed: Q4.3 (C), R34.2
unnamed: Q5.1 (G), R32.1, R37.2
unnamed: Q6.1 (G), R33.1, R38.2
unnamed: R25.2, U1.60 (BOOT0)
unnamed: R43.2, U6.3 (CH_PD)
unnamed: R44.2, U6.6 (GPIO0)
unnamed: R45.2, U6.4 (GPIO2)
unnamed: TP1.1, U1.26 (PB0)
RS485_DIR: U1.41 (PA8), U4.2 (~RE), U4.3 (DE)
SCL: J8.4, Q7.3 (D), R48.1
SDA: J8.3, Q8.3 (D), R50.1
SDIO_CK: R6.2, R20.1, U1.36 (PB15)
SDIO_CMD: R5.2, R16.1, U1.22 (PA6)
SDIO_CardDetect: J1.10 (CARD_DETECT), R12.2, U1.20 (PA4)
SDIO_D0: R7.2, R24.1, U1.39 (PC8)
SDIO_D1: R8.2, R26.1, U1.40 (PC9)
SDIO_D2: R3.2, R14.1, U1.51 (PC10)
SDIO_D3: R4.2, R15.1, U1.52 (PC11)
SDIO_WriteProtect: J1.15 (Write_Protect), R13.2, U1.21 (PA5)
SPI2_MISO: J7.3, U1.10 (PC2)
SPI2_MOSI: J7.2, U1.11 (PC3)
SPI2_SCK: J7.4, U1.29 (PB10)
SPI_CS1: J7.5, U1.8 (PC0)
USART1_RX: U1.43 (PA10), U4.1 (RO)
USART1_TX: U1.42 (PA9), U4.4 (DI)
USART2_RX: U1.17 (PA3), U6.1 (TxD)
USART2_TX: U1.16 (PA2), U6.8 (RxD)
USB+: C11.1, R34.1, R35.2, U1.45 (PA12)
USB-: C12.1, R36.2, U1.44 (PA11)
USB_Disconnect: R31.1, U1.34 (PB13)

Notes on the sheet:
I2C
CAN
USB
LEDs
SD Card
main crystal
Power
ESP
STM32 Peripherals ------------------- CAN1 = CAN @ 1Mbit/s USART1 = RS485 @ 1MBaud USART2 = ESP @ 250kBaud SPI2 = Reserved I2C1 = Reserved for PiggyBack SDIO = SD Card Interface USB_OTG_FS = Virtual Com Port
Controller
SPI Connector
Bus Connector
RTC Crystal
Grove-Port compatible
RS485

Board: 4 copper layers, 100.0 x 77.0 mm, 127 parts (0 on the bottom side), 91 nets.

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
