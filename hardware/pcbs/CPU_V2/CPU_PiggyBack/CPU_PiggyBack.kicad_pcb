# Repository Synthron/SynPLC (continued)

## KiCad design pcbs/Platinen/kicad/DI8_V1.1/DI8_V1.1.kicad_pcb (continued)

Board: 4 copper layers, 100.0 x 77.0 mm, 155 parts (0 on the bottom side), 109 nets.

## Code that names these connections

File Firmwares/STM32/CPU/F412/CPU.ioc (part):

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Mcu.Name=STM32F412R(E-G)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F412RETx
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.Mode=Device_Only
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=Device_Only
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=SDIO_CardDetect
PA4.Signal=GPIO_Input
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=SDIO_WriteProtect
PA5.Signal=GPIO_Input
PA6.Mode=SD_4_bits_Wide_bus
PA6.Signal=SDIO_CMD
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=RS485_DIR
PA8.Signal=GPIO_Output
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=TestPoint1
PB0.Signal=GPIO_Output
PB10.Mode=Full_Duplex_Master
PB10.Signal=SPI2_SCK
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=USB_Disconnect
PB13.Signal=GPIO_Output
PB15.Mode=SD_4_bits_Wide_bus
PB15.Signal=SDIO_CK
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=LED_ERROR
PB3.Signal=GPIO_Output
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=LED_RUN
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=LED_FLASH
PB5.Signal=GPIO_Output
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8.Mode=CAN_Activate
PB8.Signal=CAN1_RX
PB9.Mode=CAN_Activate
PB9.Signal=CAN1_TX
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=SPI_CS1
PC0.Signal=GPIO_Output
PC10.Mode=SD_4_bits_Wide_bus
PC10.Signal=SDIO_D2
PC11.Mode=SD_4_bits_Wide_bus
PC11.Signal=SDIO_D3
PC12.GPIOParameters=GPIO_Label
PC12.GPIO_Label=LED_BOOT
PC12.Signal=GPIO_Output
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC2.Mode=Full_Duplex_Master
PC2.Signal=SPI2_MISO
PC3.Mode=Full_Duplex_Master
PC3.Signal=SPI2_MOSI
PC8.Mode=SD_4_bits_Wide_bus
PC8.Signal=SDIO_D0
PC9.Mode=SD_4_bits_Wide_bus
PC9.Signal=SDIO_D1
PD2.GPIOParameters=GPIO_Label
PD2.GPIO_Label=LED_HEARTBEAT
PD2.Signal=GPIO_Output
PH0\ -\ OSC_IN.Mode=HSE-External-Oscillator
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PH1\ -\ OSC_OUT.Mode=HSE-External-Oscillator
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=12000000
RCC.SYSCLKFreq_VALUE=100000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File Firmwares/STM32/DO/DO.ioc (part):

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Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F103C8Tx
PA0-WKUP.GPIOParameters=GPIO_Label
PA0-WKUP.GPIO_Label=ADR0
PA0-WKUP.Signal=GPIO_Input
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=ADR1
PA1.Signal=GPIO_Input
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=CH6
PA10.Signal=GPIO_Output
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=CH7
PA11.Signal=GPIO_Output
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=CH8
PA12.Signal=GPIO_Output
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=ADR2
PA2.Signal=GPIO_Input
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=ADR3
PA3.Signal=GPIO_Input
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=ADR4
PA4.Signal=GPIO_Input
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=CH1
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=CH2
PA6.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=CH3
PA7.Signal=GPIO_Output
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=CH4
PA8.Signal=GPIO_Output
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=CH5
PA9.Signal=GPIO_Output
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=FB1
PB0.Signal=GPIO_Input
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=FB2
PB1.Signal=GPIO_Input
PB10.Mode=Asynchronous
PB10.Signal=USART3_TX
PB11.Mode=Asynchronous
PB11.Signal=USART3_RX
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=DIR
PB12.Signal=GPIO_Output
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=FB3
PB2.Signal=GPIO_Input
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=FB4
PB3.Signal=GPIO_Input
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=FB5
PB4.Signal=GPIO_Input
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=FB6
PB5.Signal=GPIO_Input
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=FB7
PB6.Signal=GPIO_Input
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=FB8
PB7.Signal=GPIO_Input
PB8.Mode=CAN_Activate
PB8.Signal=CAN_RX
PB9.Mode=CAN_Activate
PB9.Signal=CAN_TX
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2020-07-05 add pcb files
2020-07-06 add casing for DIN-Rail
2020-07-07 adding step-files
2020-07-08 update case file
2020-07-08 Deleted din-rail case/Gehaeuse.FCStd
2020-07-08 update name in case
2020-07-08 update name
2020-07-09 add tolerances to case
2020-07-17 update case with logo
2020-07-17 adding documentation
2020-07-26 Update pcbs/CPU_2020-07-26_unfinished.zip, pcbs/analog_out_2020-07-24.zip, pcbs/Output_v1.1_2020-07-24.zip, pcbs/Input_v1.0_2020-07-24.zip files
2020-07-31 update doc
2020-08-12 create code for DI
2020-08-14 update code
2020-08-20 update firmwares
2021-02-06 update Documentation
2021-02-07 update docs
2021-03-29 update rs485-spec and test-code
2021-04-03 update doc with RS485-protocol
2021-06-14 Bigger update 14.06.21
    updated PCB files
    updated documentation
    updated RS485 protocol
    updated firmwares
2021-06-15 update layout for AI
2021-06-15 fixed DRC on AO
2021-06-16 review AI V1 and AO V2
2021-06-17 updated files
2021-06-17 design of XT V1
2021-06-17 bugfixes on PCBs
2021-06-17 update simulation file
2021-06-17 Redesign XT V1
2021-06-18 start rework of DI and DO
2021-06-20 PCB update
2021-06-20 finalizing DO8_V1.2 Routing
2021-06-21 update DO8
2021-06-21 finalize DO8 layout
2021-06-21 finished layouts
2021-06-28 fix error in Schematic
2021-07-04 create todos
2021-07-05 started revs
2021-07-06 complete reviews from dave
2021-07-12 start translating documentation to english
2021-07-12 work on doc
2021-07-13 start XP module
2021-10-15 greate gerbers, plot schematics
2021-10-31 finalize PCBs; start STM32 code
2021-11-07 uodate Case CAD
2021-12-06 quick update
2022-05-15 backup commit
2022-05-20 added STM-Code
2022-05-20 DO code working!
2022-05-24 update RS485 lib
2023-04-26 Overhaul
2023-04-30 CPU Update Finish CPU V2 Design and finish CPU PiggyBack Board
2023-04-30 Overhaul Repo Cleanup Case for new CPU PiggyBack Update
2023-04-30 case design for new CPU with piggyback
2023-05-02 CPU V2 Review
2023-06-11 GPN Update: Rewrote RS485 protocol with interrupts
2024-03-05 repo transfer
2025-06-28 update rs485 protocols, debug bus garbage collection, get AO running, get AI codebase
2026-05-25 general update (too stretched out to remember what I all did)
2026-06-02 add agents
