# Repository Synthron/SynPLC (continued)

## KiCad design pcbs/Platinen/kicad/AI_V1/AI_V1.kicad_pcb

Parts:
C1, C4, C5, C6, C8, C9, C10, C11, C12, C13, C15, C16, C17, C18, C19, C20, C21, C31, C36, C43, C44: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 20p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C14, C30, C37, C42, C45: 1µ; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C22, C23, C24, C25, C32, C33, C34, C35: 10p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C26, C27, C28, C29, C38, C39, C40, C41: 10n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D7: 1N4001; D_MELF
D2, D3, D4, D5: BAV199; SOT-23
D6: SM6T36A; D_SMB
F1: PFRA 010; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
FB1, FB2, FB3, FB4: Ferrite_Bead_Small; SMB-001
FB5: Ferrite_Bead; SMB-002
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
J2, J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J5, J6: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Horizontal
J7, J8, J9, J10, J11: TBL009-500-02GY-2GY; TBL00950002GY2GY; Manufacturer_Part_Number TBL009-500-02GY-2GY; Mouser Part Number 490-TBL00950002GY2GY
Q1, Q2, Q3, Q4: PJA3440; SOT-23
R1, R3, R4, R7, R8, R9, R10, R11, R12, R13, R18, R19, R28, R29, R30, R31, R44, R45, R46, R47: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 150; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14, R15, R16, R17: 680; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R20, R22, R24, R26: 16k 0.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21, R23, R25, R27: 11k 0.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R32, R33, R34, R35: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R36, R38, R40, R42: 200R 0.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R37, R39, R41, R43: 300R 0.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_DIP_x05; DIP-10_W7.62mm_Socket
U1: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
U2: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U4: AP1117-33; SOT-223-3_TabPin2
U5: ADuM1250; SOIC-8_3.9x4.9mm_P1.27mm
U6: TLP291-4; SOIC-16_4.55x10.3mm_P1.27mm
U7, U8, U9, U10: LM358; SOIC-8_3.9x4.9mm_P1.27mm
U11: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm
U12: L78L05_SOT89; SOT-89-3
U13: L78L10_SOT89; SOT-89-3
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3V3: C4.1, C5.1, C6.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, J1.1, R1.1, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, U1.3 (VCC), U2.8 (VCC), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U4.2 (VO), U5.1 (VDD1)
+5V: C16.2, C17.2, C36.2, C37.2, R18.1, R19.1, U5.8 (VDD2), U6.10, U6.12, U6.14, U6.16, U11.8 (VDD), U12.1 (OUT)
+10V: C44.2, C45.2, D2.2, D3.2, D4.2, D5.2, D7.2 (A), U13.1 (OUT)
+24V: C18.2, C19.2, C20.2, C21.2, C30.2, C31.2, C42.2, C43.2, D7.1 (K), FB5.2, U7.8 (V+), U8.8 (V+), U9.8 (V+), U10.8 (V+), U12.3 (IN), U13.3 (IN)
BUS+: J4.4, J5.9, J6.9
BUS-: J4.3, J5.10, J6.10
CAN_RD: U1.4 (R), U3.45 (PB8)
CAN_TD: U1.1 (D), U3.46 (PB9)
CC1: R28.2, U6.15
CC2: R29.2, U6.13
CC3: R30.2, U6.11
CC4: R31.2, U6.9
DIR: U2.2 (~RE), U2.3 (DE), U3.25 (PB12)
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, J1.4, J5.5, J5.6, J5.7, J5.8, J6.5, J6.6, J6.7, J6.8, R3.2, R4.2, SW1.6, SW1.7, SW1.8, SW1.9, SW1.10, U1.2 (GND), U2.5 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.1 (GND), U5.4 (GND1), U6.2, U6.4, U6.6, U6.8
GND2: C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, D2.1, D3.1, D4.1, D5.1, D6.2 (A2), J7.1, J7.2, J8.1, J8.2, J9.1, J9.2, J10.1, J10.2, J11.3, J11.4, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R21.2, R23.2, R25.2, R27.2, R32.1, R33.1, R34.1, R35.1, U5.5 (GND2), U7.4 (V-), U8.4 (V-), U9.4 (V-), U10.4 (V-), U11.1 (ADDR), U11.3 (GND), U12.2 (GND), U13.2 (GND)
unnamed: C1.2, R1.2, U3.7 (NRST)
unnamed: C2.2, R2.2, U3.5 (PD0), Y1.1
unnamed: C3.2, R2.1, U3.6 (PD1), Y1.2
unnamed: C22.2, U7.6 (-), U7.7, U11.4 (AIN0)
unnamed: C23.2, U8.6 (-), U8.7, U11.5 (AIN1)
unnamed: C24.2, U9.6 (-), U9.7, U11.6 (AIN2)
unnamed: C25.2, U10.6 (-), U10.7, U11.7 (AIN3)
unnamed: C26.2, R20.2, R21.1, U7.5 (+)
unnamed: C27.2, R22.2, R23.1, U8.5 (+)
unnamed: C28.2, R24.2, R25.1, U9.5 (+)
unnamed: C29.2, R26.2, R27.1, U10.5 (+)
unnamed: C32.2, R20.1, U7.1, U7.2 (-)
unnamed: C33.2, R22.1, U8.1, U8.2 (-)
unnamed: C34.2, R24.1, U9.1, U9.2 (-)
unnamed: C35.2, R26.1, U10.1, U10.2 (-)
unnamed: C38.2, R44.1, U7.3 (+)
unnamed: C39.2, R45.1, U8.3 (+)
unnamed: C40.2, R46.1, U9.3 (+)
unnamed: C41.2, R47.1, U10.3 (+)
unnamed: D1.1 (K), FB5.1
unnamed: D1.2 (A), F1.2
unnamed: D2.3, FB1.1, J7.3, J7.4
unnamed: D3.3, FB2.1, J8.3, J8.4
unnamed: D4.3, FB3.1, J9.3, J9.4
unnamed: D5.3, FB4.1, J10.3, J10.4
unnamed: D6.1 (A1), F1.1, J11.1, J11.2
unnamed: FB1.2, R36.1, R44.2
unnamed: FB2.2, R38.1, R45.2
unnamed: FB3.2, R40.1, R46.2
unnamed: FB4.2, R42.1, R47.2
unnamed: J2.1, R5.1
unnamed: J2.2, J4.1, U1.6 (CANL)
unnamed: J3.1, R6.1
unnamed: J3.2, J4.5, U2.6 (A)
unnamed: J4.2, R5.2, U1.7 (CANH)
unnamed: J4.6, R6.2, U2.7 (B)
unnamed: Q1.1 (G), R28.1, R32.2
unnamed: Q1.3 (D), R37.2
unnamed: Q2.1 (G), R29.1, R33.2
unnamed: Q2.3 (D), R39.2
unnamed: Q3.1 (G), R30.1, R34.2
unnamed: Q3.3 (D), R41.2
unnamed: Q4.1 (G), R31.1, R35.2
unnamed: Q4.3 (D), R43.2
unnamed: R3.1, U3.44 (BOOT0)
unnamed: R4.1, U3.20 (PB2)
unnamed: R7.1, SW1.1, U3.10 (PA0)
unnamed: R8.1, SW1.2, U3.11 (PA1)
unnamed: R9.1, SW1.3, U3.12 (PA2)
unnamed: R10.1, SW1.4, U3.13 (PA3)
unnamed: R11.1, SW1.5, U3.14 (PA4)
unnamed: R14.1, U6.1
unnamed: R14.2, U3.29 (PA8)
unnamed: R15.1, U6.3
unnamed: R15.2, U3.30 (PA9)
unnamed: R16.1, U6.5
unnamed: R16.2, U3.31 (PA10)
unnamed: R17.1, U6.7
unnamed: R17.2, U3.32 (PA11)
unnamed: R18.2, U5.7 (VOA), U11.10 (SCL)
unnamed: R19.2, U5.6 (VOB), U11.9 (SDA)
unnamed: R36.2, R37.1
unnamed: R38.2, R39.1
unnamed: R40.2, R41.1
unnamed: R42.2, R43.1
RXD: U2.1 (RO), U3.22 (PB11)
SCL: R13.1, U3.42 (PB6), U5.2 (VIA)
SDA: R12.1, U3.43 (PB7), U5.3 (VIB)
SWCLK: J1.3, U3.37 (PA14)
SWIO: J1.2, U3.34 (PA13)
TXD: U2.4 (DI), U3.21 (PB10)
VCC: C7.1, C8.1, J5.1, J5.2, J5.3, J5.4, J6.1, J6.2, J6.3, J6.4, U4.3 (VI)

Notes on the sheet:
Galvanische Trennung mind. 1.5mm

Board: 4 copper layers, 100.0 x 77.0 mm, 135 parts (0 on the bottom side), 87 nets.

## KiCad design pcbs/Platinen/kicad/XT_V1/XT_V1.kicad_pcb

Parts:
C1, C4, C6, C7, C8, C9, C10, C11, C12, C14: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 20p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C13: 1µ; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15, C16, C17, C18: 10n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: SM4007; D_MELF
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
J2, J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J5, J6: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Horizontal
J7, J8, J9, J10: TBL009-500-02GY-2GY; TBL00950002GY2GY; Manufacturer_Part_Number TBL009-500-02GY-2GY; Mouser Part Number 490-TBL00950002GY2GY
Q1, Q2, Q3, Q4, Q5, Q7: BC846; SOT-23
Q6, Q8, Q9, Q10: BT136-500; TO-220-3_Vertical
R1, R3, R4, R7, R8, R9, R10, R11, R12, R13, R14, R15, R17, R18, R23, R24: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 150; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R19, R20, R22: max 360; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21, R26, R27, R28: 360; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R25, R30, R31, R32: 330; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R29, R35, R36, R37: 68; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R33, R34: 56k; R_MELF_MMB-0207
SW1: SW_DIP_x05; SW_DIP_SPSTx05_Slide_6.7x14.26mm_W7.62mm_P2.54mm_LowProfile
U1: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
U2: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U4: AP1117-33; SOT-223-3_TabPin2
U5, U7, U9, U10: MOC3043M; DIP-6_W8.89mm_SMDSocket_LongPads
U6, U8: TLP291; SOIC-4_4.55x2.6mm_P1.27mm
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3V3: C1.1, C6.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, J1.1, R1.1, R7.2, R8.2, R9.2, R10.2, R11.2, R13.1, R14.1, U1.3 (VCC), U2.8 (VCC), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U4.2 (VO)
BUS+: J4.4, J5.9, J6.9
BUS-: J4.3, J5.10, J6.10
CAN_RD: U1.4 (R), U3.45 (PB8)
CAN_TD: U1.1 (D), U3.46 (PB9)
CH1: R12.2, U3.29 (PA8)
CH2: R15.2, U3.30 (PA9)
CH3: R17.2, U3.10 (PA0)
CH4: R18.2, U3.11 (PA1)
DIR: U2.2 (~RE), U2.3 (DE), U3.25 (PB12)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.4, J5.5, J5.6, J5.7, J5.8, J6.5, J6.6, J6.7, J6.8, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q7.2 (E), R3.2, R4.2, SW1.6, SW1.7, SW1.8, SW1.9, SW1.10, U1.2 (GND), U2.5 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.1 (GND)
unnamed: C2.1, R2.1, U3.5 (PD0), Y1.1
unnamed: C3.1, R2.2, U3.6 (PD1), Y1.2
unnamed: C4.1, R1.2, U3.7 (NRST)
unnamed: C15.1, R35.2
unnamed: C15.2, J8.3, J8.4, Q8.1 (A1), R30.1
unnamed: C16.1, R29.2
unnamed: C16.2, J8.1, J8.2, Q6.1 (A1), R25.1
unnamed: C17.1, R36.2
unnamed: C17.2, J10.1, J10.2, Q9.1 (A1), R31.1
unnamed: C18.1, R37.2
unnamed: C18.2, J10.3, J10.4, Q10.1 (A1), R32.1
unnamed: D1.1 (K), R33.2, U6.1
unnamed: D1.2 (A), J7.1, J7.2, Q6.2 (A2), Q8.2 (A2), R21.1, R26.1, R29.1, R35.1, U6.2
unnamed: D2.1 (K), R34.2, U8.1
unnamed: D2.2 (A), J9.1, J9.2, Q9.2 (A2), Q10.2 (A2), R27.1, R28.1, R36.1, R37.1, U8.2
unnamed: J2.1, R5.1
unnamed: J2.2, J4.1, U1.6 (CANL)
unnamed: J3.1, R6.1
unnamed: J3.2, J4.5, U2.6 (A)
unnamed: J4.2, R5.2, U1.7 (CANH)
unnamed: J4.6, R6.2, U2.7 (B)
unnamed: J7.3, J7.4, R33.1
unnamed: J9.3, J9.4, R34.1
unnamed: Q1.1 (B), R12.1
unnamed: Q1.3 (C), U5.2
unnamed: Q2.1 (B), R23.2
unnamed: Q3.1 (B), R24.2
unnamed: Q4.1 (B), R15.1
unnamed: Q4.3 (C), U7.2
unnamed: Q5.1 (B), R17.1
unnamed: Q5.3 (C), U9.2
unnamed: Q6.3 (G), R25.2, U5.4
unnamed: Q7.1 (B), R18.1
unnamed: Q7.3 (C), U10.2
unnamed: Q8.3 (G), R30.2, U7.4
unnamed: Q9.3 (G), R31.2, U9.4
unnamed: Q10.3 (G), R32.2, U10.4
unnamed: R3.1, U3.44 (BOOT0)
unnamed: R4.1, U3.20 (PB2)
unnamed: R7.1, SW1.1, U3.12 (PA2)
unnamed: R8.1, SW1.2, U3.13 (PA3)
unnamed: R9.1, SW1.3, U3.14 (PA4)
unnamed: R10.1, SW1.4, U3.15 (PA5)
unnamed: R11.1, SW1.5, U3.16 (PA6)
unnamed: R16.1, U5.1
unnamed: R19.1, U7.1
unnamed: R20.1, U9.1
unnamed: R21.2, U5.6
unnamed: R22.1, U10.1
unnamed: R23.1, U6.3
unnamed: R24.1, U8.3
unnamed: R26.2, U7.6
unnamed: R27.2, U9.6
unnamed: R28.2, U10.6
RXD: U2.1 (RO), U3.22 (PB11)
SWCLK: J1.3, U3.37 (PA14)
SWIO: J1.2, U3.34 (PA13)
TXD: U2.4 (DI), U3.21 (PB10)
VCC: C5.1, C7.1, J5.1, J5.2, J5.3, J5.4, J6.1, J6.2, J6.3, J6.4, R16.2, R19.2, R20.2, R22.2, U4.3 (VI), U6.4, U8.4
ZC1: Q2.3 (C), R13.2, U3.33 (PA12)
ZC2: Q3.3 (C), R14.2, U3.38 (PA15)

Notes on the sheet:
Caps: C0805C103JARACTU (M) 56k: VIT ZC207 56K (R)
Galvanische Trennung mind. 1,5mm
AC 1
Tim1_Ch1
Tim1_Ch2
Tim2_Ch2
Tim2_Ch1

Board: 4 copper layers, 100.0 x 77.0 mm, 89 parts (0 on the bottom side), 72 nets.

## KiCad design pcbs/Platinen/kicad/DI8_V1.1/DI8_V1.1.kicad_pcb

Parts:
C1, C2: 20p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4, C6, C7, C8, C9, C10, C11, C12, C14: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C13: 1µ; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15, C16, C17, C18, C19, C20, C21, C22: 1n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C23, C24, C25, C26, C27, C28, C29, C30: 470n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_D3.0mm
D9, D10, D11, D12, D13, D14, D15, D16: 5v6; D_MiniMELF
D17, D18, D19, D20, D21, D22, D23, D24: 6v8; D_MiniMELF
D25, D26, D27, D28, D29, D30, D31, D32: LL4148; D_MiniMELF
D33, D34, D35, D36, D37, D38, D39, D40: SM6T36A; D_SMB
FB1, FB2, FB3, FB4, FB5, FB6, FB7, FB8: Ferrite_Bead; SMB-001
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J2, J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J5, J6: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Horizontal
J7, J8, J9, J10, J11: TBL009-500-02GY-2GY; TBL00950002GY2GY; Manufacturer_Part_Number TBL009-500-02GY-2GY; Mouser Part Number 490-TBL00950002GY2GY
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: BCX53; SOT-89-3
R1, R2, R4, R5, R6, R9, R10, R43, R44, R45, R46, R47, R48, R49, R50: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: 150; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R12, R13, R14, R15, R16, R17, R18: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R19, R20, R21, R22, R23, R24, R25, R26: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R27, R28, R29, R30, R31, R32, R33, R34: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R35, R36, R37, R38, R39, R40, R41, R42: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_DIP_x05; SW_DIP_SPSTx05_Slide_6.7x14.26mm_W7.62mm_P2.54mm_LowProfile
U1: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
U2: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U4: AP1117-33; SOT-223-3_TabPin2
U5, U6: TLP291-4; SOIC-16_4.55x10.3mm_P1.27mm
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3V3: C4.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.1, R1.2, R4.2, R5.2, R6.2, R9.2, R10.2, U1.3 (VCC), U2.8 (VCC), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U4.2 (VO), U5.10, U5.12, U5.14, U5.16, U6.10, U6.12, U6.14, U6.16
BUS+: J4.4, J5.9, J6.9
BUS-: J4.3, J5.10, J6.10
CAN_RD: U1.4 (R), U3.45 (PB8)
CAN_TD: U1.1 (D), U3.46 (PB9)
CH1: R11.2, U3.15 (PA5), U5.9
CH2: R12.2, U3.16 (PA6), U5.11
CH3: R13.2, U3.17 (PA7), U5.13
CH4: R14.2, U3.29 (PA8), U5.15
CH5: R15.2, U3.30 (PA9), U6.9
CH6: R16.2, U3.31 (PA10), U6.11
CH7: R17.2, U3.32 (PA11), U6.13
CH8: R18.2, U3.33 (PA12), U6.15
DIR: U2.2 (~RE), U2.3 (DE), U3.25 (PB12)
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J1.4, J5.5, J5.6, J5.7, J5.8, J6.5, J6.6, J6.7, J6.8, R2.2, SW1.6, SW1.7, SW1.8, SW1.9, SW1.10, U1.2 (GND), U2.5 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.1 (GND)
GND1: C15.1, C16.1, C17.1, C18.1, C23.1, C24.1, C25.1, C26.1, D33.2 (A2), D34.2 (A2), D35.2 (A2), D36.2 (A2), J11.1, J11.2, R19.1, R20.1, R21.1, R22.1, U5.2, U5.4, U5.6, U5.8
GND2: C19.1, C20.1, C21.1, C22.1, C27.1, C28.1, C29.1, C30.1, D37.2 (A2), D38.2 (A2), D39.2 (A2), D40.2 (A2), J11.3, J11.4, R23.1, R24.1, R25.1, R26.1, U6.2, U6.4, U6.6, U6.8
unnamed: C1.1, R3.2, U3.5 (PD0), Y1.1
unnamed: C2.2, R3.1, U3.6 (PD1), Y1.2
unnamed: C3.2, R1.1, U3.7 (NRST)
unnamed: C15.2, Q1.2 (C), R19.2, R27.2, U5.7
unnamed: C16.2, Q2.2 (C), R20.2, R28.2, U5.5
unnamed: C17.2, Q3.2 (C), R21.2, R29.2, U5.3
unnamed: C18.2, Q4.2 (C), R22.2, R30.2, U5.1
unnamed: C19.2, Q5.2 (C), R23.2, R31.2, U6.7
unnamed: C20.2, Q6.2 (C), R24.2, R32.2, U6.5
unnamed: C21.2, Q7.2 (C), R25.2, R33.2, U6.3
unnamed: C22.2, Q8.2 (C), R26.2, R34.2, U6.1
unnamed: C23.2, D25.2 (A), R43.2
unnamed: C24.2, D26.2 (A), R44.2
unnamed: C25.2, D27.2 (A), R45.2
unnamed: C26.2, D28.2 (A), R46.2
unnamed: C27.2, D29.2 (A), R47.2
unnamed: C28.2, D30.2 (A), R48.2
unnamed: C29.2, D31.2 (A), R49.2
unnamed: C30.2, D32.2 (A), R50.2
unnamed: D1.2 (A), R11.1
unnamed: D2.2 (A), R12.1
unnamed: D3.2 (A), R13.1
unnamed: D4.2 (A), R14.1
unnamed: D5.2 (A), R15.1
unnamed: D6.2 (A), R16.1
unnamed: D7.2 (A), R17.1
unnamed: D8.2 (A), R18.1
unnamed: D9.2 (A), Q1.1 (B), R27.1
unnamed: D10.1 (K), D18.2 (A), R36.1
unnamed: D10.2 (A), Q2.1 (B), R28.1
unnamed: D11.1 (K), D19.2 (A), R37.1
unnamed: D11.2 (A), Q3.1 (B), R29.1
unnamed: D12.1 (K), D20.2 (A), R38.1
unnamed: D12.2 (A), Q4.1 (B), R30.1
unnamed: D13.1 (K), D21.2 (A), R39.1
unnamed: D13.2 (A), Q5.1 (B), R31.1
unnamed: D14.1 (K), D22.2 (A), R40.1
unnamed: D14.2 (A), Q6.1 (B), R32.1
unnamed: D15.1 (K), D23.2 (A), R41.1
unnamed: D15.2 (A), Q7.1 (B), R33.1
unnamed: D16.1 (K), D24.2 (A), R42.1
unnamed: D16.2 (A), Q8.1 (B), R34.1
unnamed: D17.1 (K), D25.1 (K)
unnamed: D9.1 (K), D17.2 (A), R35.1
unnamed: D18.1 (K), D26.1 (K)
unnamed: D19.1 (K), D27.1 (K)
unnamed: D20.1 (K), D28.1 (K)
unnamed: D21.1 (K), D29.1 (K)
unnamed: D22.1 (K), D30.1 (K)
unnamed: D23.1 (K), D31.1 (K)
unnamed: D24.1 (K), D32.1 (K)
unnamed: D33.1 (A1), FB1.1, J7.1, J7.2
unnamed: D34.1 (A1), FB2.1, J7.3, J7.4
unnamed: D35.1 (A1), FB3.1, J8.1, J8.2
unnamed: D36.1 (A1), FB4.1, J8.3, J8.4
unnamed: D37.1 (A1), FB5.1, J9.1, J9.2
unnamed: D38.1 (A1), FB6.1, J9.3, J9.4
unnamed: D39.1 (A1), FB7.1, J10.1, J10.2
unnamed: D40.1 (A1), FB8.1, J10.3, J10.4
unnamed: FB1.2, R43.1
unnamed: FB2.2, R44.1
unnamed: FB3.2, R45.1
unnamed: FB4.2, R46.1
unnamed: FB5.2, R47.1
unnamed: FB6.2, R48.1
unnamed: FB7.2, R49.1
unnamed: FB8.2, R50.1
unnamed: J2.1, R7.2
unnamed: J2.2, J4.1, U1.6 (CANL)
unnamed: J3.1, R8.2
unnamed: J3.2, J4.5, U2.6 (A)
unnamed: J4.2, R7.1, U1.7 (CANH)
unnamed: J4.6, R8.1, U2.7 (B)
unnamed: Q1.3 (E), R35.2
unnamed: Q2.3 (E), R36.2
unnamed: Q3.3 (E), R37.2
unnamed: Q4.3 (E), R38.2
unnamed: Q5.3 (E), R39.2
unnamed: Q6.3 (E), R40.2
unnamed: Q7.3 (E), R41.2
unnamed: Q8.3 (E), R42.2
unnamed: R2.1, U3.44 (BOOT0)
unnamed: R4.1, SW1.1, U3.10 (PA0)
unnamed: R5.1, SW1.2, U3.11 (PA1)
unnamed: R6.1, SW1.3, U3.12 (PA2)
unnamed: R9.1, SW1.4, U3.13 (PA3)
unnamed: R10.1, SW1.5, U3.14 (PA4)
RXD: U2.1 (RO), U3.22 (PB11)
SWCLK: J1.3, U3.37 (PA14)
SWIO: J1.2, U3.34 (PA13)
TXD: U2.4 (DI), U3.21 (PB10)
VCC: C5.2, C7.2, J5.1, J5.2, J5.3, J5.4, J6.1, J6.2, J6.3, J6.4, U4.3 (VI)

Notes on the sheet:
Galvanic Isolation min. 1.5mm
